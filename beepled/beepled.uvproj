# Keil uVision project beepled.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: beepled +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\BEEP;.\App\LED;.\Public
  group App
    ./App/BEEP/: beep.c
    ./App/LED/: led.c
  group User
    ./User/: main.c
  group Public
    ./Public/: Public.c
