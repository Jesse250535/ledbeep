# Keil uVision project timeount.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: timeount +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\BEEP;.\App\smg;.\Public
  group App
    ./App/BEEP/: beep.c
    ./App/smg/: smg.c
  group User
    ./User/: main.c
  group Public
    ./Public/: Public.c
